# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\Libraries\inc;.\Libraries\src;.\User;.\HARDWARE\LED;.\User\SYS;.\HARDWARE\APP;.\HARDWARE\TASK;.\HARDWARE\IWDT;.\HARDWARE\BTIM;.\HARDWARE\KEY;.\HARDWARE\BUZZER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./User/: interrupts_cw32f030.c main.c startup_cw32f030.s
    ./User/SYS/: sys_init.c
  group HARDWARE
    ./HARDWARE/APP/: app.c
    ./HARDWARE/TASK/: task.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/IWDT/: iwdt.c
    ./HARDWARE/BTIM/: btim.c
    ./HARDWARE/BUZZER/: buzzer.c
  group Libraries
    ./Libraries/src/: cw32f030_adc.c cw32f030_atim.c cw32f030_awt.c cw32f030_btim.c cw32f030_crc.c cw32f030_debug.c cw32f030_digitalsign.c cw32f030_dma.c cw32f030_flash.c cw32f030_gpio.c cw32f030_gtim.c cw32f030_i2c.c cw32f030_iwdt.c cw32f030_lvd.c cw32f030_pwr.c cw32f030_ram.c cw32f030_rcc.c cw32f030_rtc.c cw32f030_spi.c cw32f030_systick.c cw32f030_uart.c cw32f030_vc.c cw32f030_wwdt.c system_cw32f030.c
software components: CMSIS:CORE 4.3.0
